# IAR project Backup (3) of Concentrator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151ZE ST STM32L151ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L1XX_HD; USE_STDPERIPH_DRIVER; USE_STM32L152_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\LIB\STM32L1xx_StdPeriph_Lib_V1.3.0\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\LIB\STM32L1xx_StdPeriph_Lib_V1.3.0\Libraries\STM32L1xx_StdPeriph_Driver; ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\IAR\ARM_CM3; ..\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Concentrator.hex
  ILINK.IlinkOutputFile: Concentrator.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../../BSP/scr/: DriverPcb.c MB85RC512T.c MCU_Config.c PCF8563.c SerialPort.c
  group FreeRTOS/MEM
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Port
    ../../FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group LIB/Common
    ../../LIB/Common/src/: Common_API.c SofTimer.c
  group LIB/FLT
    ../../LIB/FLT/: filter.c
  group LIB/STM32L1xx/EWARM
    ../../LIB/STM32L1xx_StdPeriph_Lib_V1.3.0/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_xl.s
  group LIB/STM32L1xx/StdPeriph_Driver
    ../../LIB/STM32L1xx_StdPeriph_Lib_V1.3.0/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Project
    ../inc/: FreeRTOSConfig.h
    ../src/: main.c stm32_it.c system_stm32l1xx.c
  group User
    ../../User/scr/: CJT-188-2004.c CRC8.C Gprs.c Manual.c MeterList.c OnSceneComm.c Server188.c SystemInit.c
    ../../User/inc/: Includes.h
